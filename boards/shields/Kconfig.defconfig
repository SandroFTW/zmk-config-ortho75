## boards/shields/Kconfig.defconfig
```kconfig
# Copyright (c) 2020 The ZMK Contributors
# SPDX-License-Identifier: MIT

if SHIELD_ORTHO75

config ZMK_KEYBOARD_NAME
    default "ortho75"

endif
```
